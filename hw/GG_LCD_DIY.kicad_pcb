# Repository Trirosmos/pico_gg_lcd

File README.md:

## Pico GG LCD

RP2040-based Game Gear screen replacement kit.
Even a cheapo modern LCD has much, much, much better contrast ratio than the OG screen.

## Building the software

Clone this repository and pull all submodules:
```Bash
git clone https://github.com/Trirosmos/pico_gg_lcd
cd pico_gg_lcd
git submodule update --init --recursive
```

Then, run `sw/build.sh`:

```Bash
cd sw
mkdir build
cd build
cmake ../CMakeLists.txt
make
```

This should generate an uf2 file you can upload to the RP2040;

## Building the hardware

Componentes you'll need and their approximate cost:

- Pico GG LCD PCB ($5)
- [PMOD HDMI adapter board](https://aliexpress.com/w/wholesale-pmod%2525252dhdmi.html?spm=a2g0o.detail.search.0) ($4) 
- [54-pin FPC connector adapter board](https://aliexpress.com/item/32827105259.html) ($2)
- [LQ035NC111 LCD module](https://aliexpress.com/w/wholesale-LQ035NC111.html?spm=a2g0o.home.search.0) ($10)
- [RP2040 board that exposes all 30 GPIOs](https://aliexpress.com/item/1005003796653297.html) ($4)
- BS170 or similar NMOSFET ($0.3)
- ~470uH axial THT inductor ($0.2)
- 2x SOD-123 Schottky diode ($0.4)
- 10k 0805 resistor ($0.05)
- 100k 0805 resistor ($0.05)
- 100nF 0805 resistor ($0.05)
- 100uF 0805 resistor ($0.05)
- 22uF 0805 resistor ($0.05)

Total approximate BOM cost: $26

First assemble passive components and transistor, then the RP2040 board and leave the FPC connector to be connected last.
The final board should look something like this, sans the bodge wire:

## How Game Gear video signals work

The Game Gear ASIC generates digital video signals that the LCD drivers in the LCD ribbon use to drive the actual display segments.

In NTSC mode, i.e, when test pad T10 is connected to +5V, the timings of the signals from the ASIC closely resemble what one would expect from a console like the Master System. All screen replacement kits run the Game Gear in this mode, as far as I'm aware. 

The communication protocol used between the ASIC and the LCD drivers in this mode is [well documented](https://www.retrosix.wiki/va0va1-lcd-interface-game-gear) and essentially boils down to:

- 32 MHz pixel clock (same as the main system clock)
- 4 bit data bus carrying one channel of color data at a time
- VSync signal
- HSync signal

## How the RP2040 captures GG video

One of the PIOs is takes alongside three DMA channels with building a live framebuffer in RAM with the image data the GG is sending out.

Three PIO SMs are used in the following manner:

- SM0 detects when a frame starts and triggers an IRQ.
- SM1 detects the IRQ from SM0 and starts detecting HSync pulses. It triggers an IRQ when it does.
- SM2 detects the IRQ from SM1 and proceeds to capture pixel data and push it out to the RX FIFO.

One of the DMA channels then takes the 12bpp pixel data from the PIO RX FIFO and saves it into RAM.

Finally, one of the CPU cores upscales the image and sends it out to the LCD.

## KiCad design hw/GG_LCD_DIY.kicad_pcb

Parts:
C1: 100n; C_0805_2012Metric
C2: 100u; C_0805_2012Metric
C3: 22u; C_0805_2012Metric
D1: D_Schottky; D_SOD-123
D3: D; D_SOD-123
J1: Bright; TestPoint_Pad_2.0x2.0mm
J2: D1; TestPoint_Pad_2.0x2.0mm
J3: D2; TestPoint_Pad_2.0x2.0mm
J4: D3; TestPoint_Pad_2.0x2.0mm
J5: D4; TestPoint_Pad_2.0x2.0mm
J6: CL2; TestPoint_Pad_2.0x2.0mm
J7: DW; TestPoint_Pad_2.0x2.0mm
J8: CLK; TestPoint_Pad_2.0x2.0mm
J9: SMS; TestPoint_Pad_2.0x2.0mm
J10: LEFT; TestPoint_Pad_2.0x2.0mm
J11: RIGHT; TestPoint_Pad_2.0x2.0mm
J12: START; TestPoint_Pad_2.0x2.0mm
J14: Conn_01x60; FPC_60_Adapter
J15: +5V; TestPoint_Pad_2.0x2.0mm
J16: GND; TestPoint_Pad_2.0x2.0mm
J17: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal
L1: 470u; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
Q2: 2N2222; TO-92
R1: 100k; R_0805_2012Metric
R2: 10k; R_0805_2012Metric
U1: ChinaPico; RPi_Pico_SMD_TH

Connections:
+3V3: J14.41, J14.42, J14.50, J17.1, J17.2, U1.36 (3V3)
+5V: C2.1, C3.1, D1.1 (K), L1.1, U1.39 (VIN)
+20V: C1.1, D3.1 (K), J14.3, J14.4, R1.1
FDBCK: R1.2, R2.1, U1.32 (GPIO28)
GND: C1.2, C2.2, C3.2, J14.1, J14.2, J14.12, J14.13, J14.14, J14.15, J14.16, J14.17, J14.18, J14.19, J14.20, J14.21, J14.22, J14.23, J14.24, J14.25, J14.26, J14.27, J14.28, J14.29, J14.30, J14.31, J14.48, J14.49, J14.53, J14.54, J16.1, J17.3, J17.4, Q2.3 (E), R2.2, U1.6 (GND), U1.15 (GND), U1.29 (AGND), U1.35 (GND), U1.38 (GND)
HDMI_CLK+: J17.6, U1.5 (GPIO4)
HDMI_CLK-: J17.5, U1.7 (GPIO5)
HDMI_D0+: J17.8, U1.26 (GPIO23)
HDMI_D0-: J17.7, U1.27 (GPIO24)
HDMI_D1+: J17.10, U1.3 (GPIO2)
HDMI_D1-: J17.9, U1.4 (GPIO3)
HDMI_D2+: J17.12, U1.1 (GPIO0)
HDMI_D2-: J17.11, U1.2 (GPIO1)
LCD_Backlight: Q2.2 (B), U1.17 (GPIO14)
LCD_CLK: J14.38, U1.31 (GPIO27)
LCD_D0: J14.32, U1.9 (GPIO7)
LCD_D1: J14.33, U1.10 (GPIO8)
LCD_D2: J14.34, U1.11 (GPIO9)
LCD_D3: J14.35, U1.12 (GPIO10)
LCD_DEN: J14.52, U1.30 (GPIO26)
LCD_HSync: J14.36
LCD_RST: J14.8, U1.8 (GPIO6)
LCD_VSync: J14.37
LED_PIN: U1.28 (GPIO25)
unnamed: D1.2 (A), J15.1
unnamed: D3.2 (A), L1.2, Q2.1 (C)
unnamed: J1.1, U1.33 (GPIO29)
unnamed: J2.1, U1.19 (GPIO16)
unnamed: J3.1, U1.20 (GPIO17)
unnamed: J4.1, U1.21 (GPIO18)
unnamed: J5.1, U1.22 (GPIO19)
unnamed: J6.1, U1.24 (GPIO21)
unnamed: J7.1, U1.23 (GPIO20)
unnamed: J8.1, U1.25 (GPIO22)
unnamed: J9.1, U1.18 (GPIO15)
unnamed: J10.1, U1.14 (GPIO12)
unnamed: J11.1, U1.13 (GPIO11)
unnamed: J12.1, U1.16 (GPIO13)

Board: 2 copper layers, 97.2 x 59.0 mm, 26 parts (0 on the bottom side), 35 nets.

## KiCad design hw/Pico_GG_LCD.kicad_pcb

Parts:
C1, C4, C11, C21, C22, C23, C24, C25, C28, C31, C32: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C10, C26, C29: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C19: 15p; C_0603_1608Metric
C6: 470p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C8: 22u; C_0603_1608Metric
C9: 10u; C_0603_1608Metric
C12: 68u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13: 100u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14: 1u; C_0603_1608Metric
C15: 100n; C_0603_1608Metric
D1, D2: D_Schottky; D_SOD-123; LCSC C8598
D3: 1N5819; D_SOD-323
J1: D1; TestPoint_Pad_2.0x2.0mm
J2: D2; TestPoint_Pad_2.0x2.0mm
J3: D3; TestPoint_Pad_2.0x2.0mm
J4: D4; TestPoint_Pad_2.0x2.0mm
J5: CL2; TestPoint_Pad_2.0x2.0mm
J6: DW; TestPoint_Pad_2.0x2.0mm
J7: CLK; TestPoint_Pad_2.0x2.0mm
J8: SMS; TestPoint_Pad_2.0x2.0mm
J9: HDMI_A; HDMI_A_Amphenol_10029449-x01xLF_Horizontal; LCSC C427307
J11: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J12: LEFT; TestPoint_Pad_2.0x2.0mm
J13: RIGHT; TestPoint_Pad_2.0x2.0mm
J14: START; TestPoint_Pad_2.0x2.0mm
J15: RESET; TestPoint_Pad_2.0x2.0mm
J16: HDGC-0.5K-DX-54PWB; FPC_54; LCSC C2911871
J17: +5V; TestPoint_Pad_2.0x2.0mm
J18: GND; TestPoint_Pad_2.0x2.0mm
J19: Bright; TestPoint_Pad_2.0x2.0mm
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 100u; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder; LCSC C404483
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_Jing_918-418K2023S40001; LCSC C167321
Q3: Q_NMOS_GSD; SOT-23; LCSC C20917
R1, R2, R3, R4, R7, R11, R14: 10k; R_0603_1608Metric
R5: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 180; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 0.54; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R13: 1k; R_0603_1608Metric
R12, R15, R19, R20, R21, R22, R23, R24: 270; R_0603_1608Metric
R16, R17: 27; R_0603_1608Metric
R18: 5.1k; R_0603_1608Metric
U1, U4: 74LVC245; TSSOP-20_4.4x6.5mm_P0.65mm; LCSC C7848
U2: MC34063AD; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C5349988
U3: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186
U5: W25Q128JVSIQ; SOIC-8_5.23x5.23mm_P1.27mm; LCSC C97521
U7: RP2040; RP2040-QFN-56; LCSC C2040
Y2: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C20625731

Connections:
+1V1: C29.2, C31.2, C32.2, U7.23 (DVDD), U7.45 (VREG_VOUT), U7.50 (DVDD)
+3V3: C1.1, C2.1, C3.1, C4.1, C7.1, C9.1, C10.1, C11.1, C14.1, C15.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C28.1, J16.41, J16.42, J16.50, R1.2, R2.2, R11.2, R14.2, U1.20 (VCC), U3.2 (VO), U4.20 (VCC), U5.8 (VCC), U7.1 (IOVDD), U7.10 (IOVDD), U7.22 (IOVDD), U7.33 (IOVDD), U7.42 (IOVDD), U7.43 (ADC_AVDD), U7.44 (VREG_IN), U7.48 (USB_VDD), U7.49 (IOVDD)
+5VD: C8.1, C13.2, D1.1 (K), D2.1 (K), J9.18 (+5V), R7.2, R9.2, U2.6 (Vin), U3.3 (VI)
+20V: C12.2, D3.1 (K), J16.3, J16.4, R6.2
Backlight_GND: J16.1, J16.2, Q3.3 (D)
CL2: U4.14 (B4), U7.32 (GPIO21)
CLK: U4.12 (B6), U7.34 (GPIO22)
D01_Pico: U4.18 (B0), U7.27 (GPIO16)
D02_Pico: U4.17 (B1), U7.28 (GPIO17)
D03_Pico: U4.16 (B2), U7.29 (GPIO18)
D04_Pico: U4.15 (B3), U7.30 (GPIO19)
DOWN_Pico: U1.17 (B1)
DW: U4.13 (B5), U7.31 (GPIO20)
FLASH_CLK: U5.6 (SCK), U7.52 (QSPI_SCLK)
FLASH_D0: U5.5 (SI/IO0), U7.53 (QSPI_SD0)
FLASH_D1: U5.2 (SO/IO1), U7.55 (QSPI_SD1)
FLASH_D2: U5.3 (~WP/IO2), U7.54 (QSPI_SD2)
FLASH_D3: U5.7 (~HOLD/IO3), U7.51 (QSPI_SD3)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C19.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C28.2, C29.1, C31.1, C32.1, J9.2 (D2S), J9.5 (D1S), J9.8 (D0S), J9.11 (CKS), J9.17 (GND), J9.SH, J11.2, J16.12, J16.13, J16.14, J16.15, J16.16, J16.17, J16.18, J16.19, J16.20, J16.21, J16.22, J16.23, J16.24, J16.25, J16.26, J16.27, J16.28, J16.29, J16.30, J16.31, J16.48, J16.49, J16.53, J16.54, J18.1, JP2.2 (B), P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), Q3.2 (S), R3.2, R4.2, R5.1, R18.1, U1.10 (GND), U2.2 (SwE), U2.4 (GND), U3.1 (GND), U4.10 (GND), U5.4 (GND), U7.19 (TESTEN), U7.57 (GND), Y2.2, Y2.4; also elsewhere on the board
HDMI_CLK+: R23.2, U7.6 (GPIO4)
HDMI_CLK-: R24.2, U7.7 (GPIO5)
HDMI_D0+: R21.2, U7.36 (GPIO24)
HDMI_D0-: R22.2, U7.37 (GPIO25)
HDMI_D1+: R19.2, U7.4 (GPIO2)
HDMI_D1-: R20.2, U7.5 (GPIO3)
HDMI_D2+: R12.2, U7.2 (GPIO0)
HDMI_D2-: R15.2, U7.3 (GPIO1)
LCD_Backlight: Q3.1 (G), U7.14 (GPIO11)
LCD_CLK: J16.38, U7.16 (GPIO13)
LCD_D0: J16.32, U7.9 (GPIO7)
LCD_D1: J16.33, U7.11 (GPIO8)
LCD_D2: J16.34, U7.12 (GPIO9)
LCD_D3: J16.35, U7.13 (GPIO10)
LCD_DEN: J16.52, U7.17 (GPIO14)
LCD_HSync: J16.36
LCD_RST: J16.8, U7.15 (GPIO12)
LCD_VSync: J16.37
LED_PIN: U7.35 (GPIO23); also elsewhere on the board
LEFT_Pico: U1.16 (B2), U7.38 (GPIO26_ADC0)
unnamed: C5.2, R13.1, Y2.1
unnamed: D1.2 (A), J17.1
unnamed: D2.2 (A), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS)
unnamed: D3.2 (A), L1.1, U2.1 (SwC)
unnamed: J1.1, U4.2 (A0)
unnamed: J2.1, U4.3 (A1)
unnamed: J3.1, U4.4 (A2)
unnamed: J4.1, U4.5 (A3)
unnamed: J5.1, U4.6 (A4)
unnamed: J6.1, U4.7 (A5)
unnamed: J7.1, U4.8 (A6)
unnamed: J8.1, U4.9 (A7)
unnamed: J9.10 (CK+), R23.1
unnamed: J9.12 (CK-), R24.1
unnamed: J9.7 (D0+), R21.1
unnamed: J9.9 (D0-), R22.1
unnamed: J9.4 (D1+), R19.1
unnamed: J9.6 (D1-), R20.1
unnamed: J9.1 (D2+), R12.1
unnamed: J9.3 (D2-), R15.1
unnamed: J11.6, R10.2
unnamed: J12.1, U1.4 (A2)
unnamed: J13.1, U1.5 (A3)
unnamed: J14.1, U1.6 (A4)
unnamed: J15.1, U1.7 (A5)
unnamed: J19.1, R7.1, U7.41 (GPIO29_ADC3)
unnamed: P1.A5 (CC), R18.2
unnamed: P1.A6 (D+), R16.2
unnamed: P1.A7 (D-), R17.2
unnamed: R1.1, U1.1 (A->B)
unnamed: R4.1, U1.19 (CE)
unnamed: R8.2, U2.8 (DC)
unnamed: L1.2, R8.1, R9.1, U2.7 (Ipk)
unnamed: C6.2, U2.3 (TC)
unnamed: R5.2, R6.1, U2.5 (Vfb)
unnamed: R2.1, U4.1 (A->B)
unnamed: R3.1, U4.19 (CE)
unnamed: R17.1, U7.46 (USB_DM)
unnamed: R16.1, U7.47 (USB_DP)
unnamed: C19.2, U7.20 (XIN), Y2.3
unnamed: R13.2, U7.21 (XOUT)
RESET_Pico: U1.13 (B5), U7.8 (GPIO6)
RIGHT_Pico: U1.15 (B3), U7.39 (GPIO27_ADC1)
RUN: J11.5, JP2.1 (A), R14.1, U7.26 (RUN)
SMS: U4.11 (B7), U7.18 (GPIO15)
START_Pico: U1.14 (B4), U7.40 (GPIO28_ADC2)
SWCLK: J11.3, U7.24 (SWCLK)
SWD: J11.1, U7.25 (SWD)
UP_Pico: U1.18 (B0)
~FLASH_CS: R10.1, R11.1, U5.1 (~CS), U7.56 (QSPI_SS)

Notes on the sheet:
Tantalum caps
Low ESR caps

Board: 4 copper layers, 97.2 x 67.5 mm, 84 parts (0 on the bottom side), 86 nets.

Other parts of the board:
D4: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R25: 270; R_0603_1608Metric

Their connections:
GND: D4.1 (K); also elsewhere on the board
LED_PIN: R25.1; also elsewhere on the board
unnamed: D4.2 (A), R25.2

File hw/jlcpcb/production_files/BOM-Pico_GG_LCD.csv:

Comment,Designator,Footprint,LCSC
USB_C_Plug_USB2.0,P1,USB_C_Receptacle_Jing_918-418K2023S40001,C167321
1N5819,D3,D_SOD-323,C191023
RP2040,U7,RP2040-QFN-56,C2040
Crystal_GND24,Y2,Crystal_SMD_3225-4Pin_3.2x2.5mm,C20625731
Q_NMOS_GSD,Q3,SOT-23,C20917
HDGC-0.5K-DX-54PWB,J16,FPC_54,C2911871
100u,L1,L_0805_2012Metric_Pad1.05x1.20mm_HandSolder,C404483
HDMI_A,J9,HDMI_A_Amphenol_10029449-x01xLF_Horizontal,C427307
MC34063AD,U2,SOIC-8_3.9x4.9mm_P1.27mm,C5349988
AMS1117-3.3,U3,SOT-223-3_TabPin2,C6186
74LVC245,"U1,U4",TSSOP-20_4.4x6.5mm_P0.65mm,C7848
D_Schottky,"D1,D2",D_SOD-123,C8598
W25Q128JVSIQ,U5,SOIC-8_5.23x5.23mm_P1.27mm,C97521
1k,R10,R_0603_1608Metric,
10k,R11,R_0603_1608Metric,
100n,C15,C_0603_1608Metric,
1u,C14,C_0603_1608Metric,
100n,C11,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
10k,R1,R_0603_1608Metric,
15p,C19,C_0603_1608Metric,
15k,R6,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,
56u,C12,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
10k,R3,R_0603_1608Metric,
10k,R7,R_0603_1608Metric,
100n,C4,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
100n,C31,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
15p,C5,C_0603_1608Metric,
10k,R14,R_0603_1608Metric,
100n,C22,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
10k,R4,R_0603_1608Metric,
1u,C10,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
462p,C6,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
100n,C32,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
22u,C8,C_0603_1608Metric,
100n,C25,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
0.5357,R9,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,
100n,C24,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
180,R8,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,
1u,C2,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
27,R17,R_0603_1608Metric,
10u,C9,C_0603_1608Metric,
1u,C29,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
27,R16,R_0603_1608Metric,
100n,C28,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
1u,C26,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
22u,C7,C_0603_1608Metric,
100n,C21,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
100u,C13,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
5.1k,R18,R_0603_1608Metric,
10k,R2,R_0603_1608Metric,
100n,C1,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
100n,C23,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
1k,R5,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,
1u,C3,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,
1k,R13,R_0603_1608Metric,

## Code that names these connections

File sw/src/main.c (part):

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
#define dw 20
#define cl2  21
#define led_pin 25
#define SMS_pin 15
#define pixels_in_scanline 300
#define scanlines_in_active_area 192

#define lcd_D0 7
#define lcd_D1 8
#define lcd_D2 9
#define lcd_D3 10
#define lcd_den 26
#define lcd_clk 27
#define lcd_rst 6
#define lcd_backlight 14

#define fdbck 28

#define brightness_pot 29

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		uint32_t y_base = base - ((y * 310) >> 9) * pixels_in_scanline + 256;

		//Tell LCD we're starting the active portion of the scanline
		gpio_put(lcd_den, 0);

		///unpack transforms 0b0000rrrrggggbbbb word into 0bbbb000000gggg000000rrrr word
		//Channel order is changed to bgr because that's what the LCD expects
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		}

		//Signal end of active scanline portion
		gpio_put(lcd_den, 1);

		//Send empty pixels during Hblank
		for(uint32_t wait = 0; wait < lcd_hblank_len; wait ++) {
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	}

	//Start of vblank
	gpio_put(lcd_den, 1);

	//Send empty data for the entirety of vblank
	for(uint32_t wait_line = 0; wait_line < lcd_blank_lines; wait_line ++) {
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	}
}

//The only thing that changes for SMS mode are the scaling constants
//However, putting those values in variables considerably slows down this function
//So, instead, we use magic constants baked into the code
__attribute__ ((long_call, section (".time_critical"))) void update_lcd_sms() {	
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	{
		uint32_t y_base = base - ((y * 413) >> 9) * pixels_in_scanline;

		gpio_put(lcd_den, 0);

		uint32_t old_pix_value = unpack(curr_framebuffer[y_base] & 4095);

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			pio_sm_put(pio1, 0, pix_value & 15);
		}

		gpio_put(lcd_den, 1);

		for(uint32_t wait = 0; wait < lcd_hblank_len; wait ++) {
			pio_sm_put_blocking(pio1, 0, 0);
		}
	}

	gpio_put(lcd_den, 1);

	for(uint32_t wait_line = 0; wait_line < lcd_blank_lines; wait_line ++) {
		for(uint32_t pixel = 0; pixel < lcd_width; pixel ++) {
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	uint8_t lcd_send = pio_add_program(pio1, &lcd_send_program);
	pio_sm_config lcd_send_config = lcd_send_program_get_default_config(lcd_send);
	sm_config_set_clkdiv(&lcd_send_config, 1);
	sm_config_set_sideset_pins(&lcd_send_config, lcd_clk);
	sm_config_set_out_pins(&lcd_send_config, lcd_D0, 4);
	sm_config_set_out_shift(&lcd_send_config, true, false, 32);
	sm_config_set_in_shift(&lcd_send_config, false, false, 32);

	pio_gpio_init(pio1, lcd_clk);
	pio_gpio_init(pio1, lcd_D0);
	pio_gpio_init(pio1, lcd_D1);
	pio_gpio_init(pio1, lcd_D2);
	pio_gpio_init(pio1, lcd_D3);

	pio_sm_set_pindirs_with_mask(pio1, 0, (1 << lcd_clk), (1 << lcd_clk));
	pio_sm_set_pindirs_with_mask(pio1, 0, (1 << lcd_D0), (1 << lcd_D0));
	pio_sm_set_pindirs_with_mask(pio1, 0, (1 << lcd_D1), (1 << lcd_D1));
	pio_sm_set_pindirs_with_mask(pio1, 0, (1 << lcd_D2), (1 << lcd_D2));
	pio_sm_set_pindirs_with_mask(pio1, 0, (1 << lcd_D3), (1 << lcd_D3));
	pio_sm_init(pio1, 0, lcd_send, &lcd_send_config);
	pio_sm_set_enabled(pio1, 0, true);

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void config_backlight_supply(uint8_t pwm_backlight_slice) {
	adc_init();
	adc_select_input(fdbck - 26);
	adc_gpio_init(fdbck);
	adc_run(true);
	adc_fifo_setup(true, false, 0, 0, 0);

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			pwm_hw->slice[pwm_backlight_slice].cc -= 10;
		}

		gpio_put(led_pin, !gpio_get(led_pin));
	}*/
	pwm_hw->slice[pwm_backlight_slice].cc = 3500;
	//pwm_hw->slice[pwm_backlight_slice].cc = 20;
}

uint8_t config_backlight_pwm() {
	gpio_set_function(lcd_backlight, GPIO_FUNC_PWM);
	pwm_backlight_slice = pwm_gpio_to_slice_num(lcd_backlight);

	pwm_config config = pwm_get_default_config();
	pwm_config_set_phase_correct(&config, false);
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}

void init_lcd() {
	gpio_put(lcd_rst, 1);
	sleep_ms(10);
	gpio_put(lcd_rst, 0);
	sleep_ms(10);
	gpio_put(lcd_rst, 1);
}

void fill_framebuffer_with_test_pattern() {
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	stdio_init_all();

	gpio_init_mask(0b11111111111111111111111111111111);
	gpio_set_dir_out_masked(1 << led_pin);
	gpio_set_dir_out_masked(1 << lcd_rst);
	gpio_set_dir_out_masked(1 << lcd_den);
	gpio_set_dir_out_masked(1 << lcd_backlight);

	uint8_t pwm_backlight_slice = config_backlight_pwm();
	config_backlight_supply(pwm_backlight_slice);
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
	multicore_launch_core1(core1_main);

	gpio_put(lcd_den, 1);
	gpio_put(lcd_clk, 0);
	gpio_put(lcd_backlight, 0);

	adc_init();
	adc_select_input(brightness_pot - 26);
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
	while(1) {
		last_gg = gg_now;
		gg_now = !gpio_get(SMS_pin);

		if(last_gg == gg_now) is_gg = gg_now;

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
## Commit log

2024-06-21 Initial commit.
2024-06-21 Add empty readme
2024-06-22 Add new image.
2024-06-22 Add licence.
2024-06-24 Start custom PCB
2024-06-29 Start work on standalone PCB
2024-06-29 Add HDMI connector
2024-06-29 Fix HDMI connector orientation
2024-06-29 Define PCB shape to fit in GG motherboard screwholes
2024-06-29 Leave HDMI connector out of the way of the LCD ribbon
2024-06-30 Add component values for boost converter
2024-06-30 Can't forget about the flash memory, duh
2024-06-30 Add JLCPCB manufacturing data
2024-06-30 Add IC pin marker
2024-06-30 Add better readme
2024-06-30 Fix HDMI connections (thanks, willbritton)
2024-06-30 Add indicator LED
2024-07-05 DIY board version
2024-07-05 Nudge PMOD connector a bit
2024-07-23 Change scaling factors in GG mode
2024-08-17 New FPC connector position; Fix LCD pin order;
2024-08-29 Cleanup
2024-08-29 Update board image for DIY version
2025-02-22 Final touches
2025-05-25 LQ035NC111 release
2025-05-25 Fix links
2025-05-25 Clarify README build instructions
